# IAR project Start.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\; inc\
  XLINK.XclFile: ETC\at91SAM7S64_NoRemap.xcl
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: ETC\at91SAM7S64_16KRAM.xcl
  group Application
    Application/: interrupt_timer.c interrupt_Usart.c main.c
  group Cstartup
    CSTARTUP/: Cstartup.s79 Cstartup_SAM7.c
