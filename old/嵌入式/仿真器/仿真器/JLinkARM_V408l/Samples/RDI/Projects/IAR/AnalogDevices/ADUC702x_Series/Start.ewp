# IAR project Start.ewp, settings and files
configuration Debug_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ETC\ADI702x_FLASH.xcl
configuration Debug_RAM (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: ETC\ADI702x_RAM.xcl
configuration Release (ARM)
  as the first configuration, except:
  group Application
    Application/: XIRQ0.c
  group CStartup
    CStartup/: cstartup.s79
  group ETC
    ETC/: ADI702x_FLASH.xcl ADI702x_RAM.xcl
