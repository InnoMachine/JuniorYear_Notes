# IAR project Lpc213x_demo.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2138 Philips LPC2138
  ICCARM.CCIncludePath2: App\; Board\; modules\; ; C:\Program Files\IAR Systems\Embedded Workbench 4.0 Evaluation\arm\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: LPC2138_RAM.xcl
configuration Debug flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FLASH
  XLINK.XclFile: LPC2138_flash.xcl
  group (top)
    app/: demo.c user_func.c
  group Common Source
    board/: lpc2xxx_cstartup.s79
  group Modul Source
    modules/: drv_hd44780.c LPC_Rtc.c LPC_SysControl.c LPC_Timer.c LPC_Uart.c LPC_Vic.c menu.c
