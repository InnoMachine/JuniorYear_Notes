# IAR project Start.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  ICCARM.CCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ETC\str710_eval_flash.xcl
configuration Debug_RAM (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  XLINK.XclFile: ETC\str710_eval_ram.xcl
configuration Release (ARM, debug)
  as the first configuration, except:
  group Application
    Application/: STR71xF_Example.c
  group CStartup
    CStartup/: cstartup.s79
  group ETC
    ETC/: str710_eval_flash.xcl str710_eval_ram.xcl
