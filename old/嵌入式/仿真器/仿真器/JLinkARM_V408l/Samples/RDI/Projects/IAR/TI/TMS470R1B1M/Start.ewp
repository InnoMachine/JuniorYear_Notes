# IAR project Start.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinb8n.h
  General.OGChipSelectEditMenu: TMS470R1B1M TexasInstruments TMS470R1B1M
  ICCARM.CCIncludePath2: Application
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ETC\TMS470R1B1M_RAM.xcl
configuration Flash (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: ETC\TMS470R1B1M_Flash.xcl
  group Application
    Application/: Main.c
  group CStartup
    CStartup/: cstartup.s79
